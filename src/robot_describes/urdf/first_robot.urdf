Commit message: feat: use xacro

File: src/robot_describes/urdf/first_robot.urdf (robot description, URDF)
Before this commit: robot first_robot, 2 links, 1 joints
Links:
- removed link base_link
- removed link imu_link
Joints:
- removed joint imu_joint
